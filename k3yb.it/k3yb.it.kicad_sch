File: k3yb.it/k3yb.it.kicad_sch (KiCad schematic)
At the start: 223 parts, among them U1 Nice_Nano_V2, U2 4052, U5 CD74HC4067M

Commit message: fixed LED schematics
Parts:
- removed D96: AUDIO ON, LED_THT:LED_D3.0mm, symbol Device:LED
- removed R5: 180, Resistor_THT:R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal, symbol ScottoKeebs:Placeholder_Resistor
Connections:
- net AUDIO ON LED is gone; now on net LED_OUTPUT: U2.12 (X0)
- net BLOC SCORR LED: now also U2.2 (Y2); no longer U2.11 (X3)
- net CAPS LOCK LED: now also U2.5 (Y1); no longer U2.15 (X2)
- net MIC ON LED: now also U2.4 (Y3); no longer U2.14 (X1)
- net LED_OUTPUT: now reaches U1.12 (D9)
- net LED_OUTPUT: now also U2.11 (X3), U2.14 (X1), U2.15 (X2)
- no-connect marks 5 -> 1
Other:
- moved on the sheet: D95, R4

Commit message: added Gerber fixed led output multiplexing
Connections:
- net +3.3V: now also U2.11 (X3), U2.12 (X0), U2.14 (X1), U2.15 (X2); no longer U2.13 (X), U2.3 (Y)
- net GND: no longer U2.6 (Inh)
- net LED_OUTPUT: now also U2.6 (Inh); no longer U2.11 (X3), U2.12 (X0), U2.14 (X1), U2.15 (X2)
- new net: U2.13 (X), U2.3 (Y)
Changed lines of the file:
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@@
   (junction (at 129.54 154.94) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 191.77 236.22) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 139.7 99.06) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 124.46 142.24) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 191.77 228.6) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 245.11 120.65) (diameter 0) (color 0 0 0 0)
   )
@@
   )
   (junction (at 85.09 68.58) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 179.07 228.6) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 234.95 198.12) (diameter 0) (color 0 0 0 0)
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 179.07 228.6) (xy 161.29 228.6))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 161.29 228.6) (xy 161.29 240.03))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 372.11 77.47) (xy 372.11 142.24))
     (stroke (width 0) (type default))
@@
   )
   (wire (pts (xy 109.22 142.24) (xy 109.22 185.42))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 191.77 228.6) (xy 191.77 236.22))
     (stroke (width 0) (type default))
   )
@@
     )
   )
-  (global_label "LED_OUTPUT" (shape input) (at 161.29 240.03 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 146.6934 240.03 0)
-      (effects (font (size 1.27 1.27)) (justify right) hide)
-    )
-  )
   (global_label "Pad Col 1" (shape output) (at 290.83 245.11 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
@@
     )
   )
+  (global_label "LED_OUTPUT" (shape input) (at 166.37 259.08 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 151.7734 259.08 0)
+      (effects (font (size 1.27 1.27)) (justify right) hide)
+    )
+  )
   (global_label "Col 3" (shape input) (at 388.62 222.25 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
@@
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
-  )
-  (global_label "LOW" (shape input) (at 166.37 259.08 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 159.5748 259.08 0)
-      (effects (font (size 1.27 1.27)) (justify right) hide)
-    )

Commit message: added dxf, added reset switch
Parts:
- added SW1: Nice!Nano Reset, Button_Switch_THT:SW_PUSH_1P1T_6x3.5mm_H4.3_APEM_MJTP1243, symbol Switch:SW_Push_Dual_x2
Connections:
- net GND: now also SW1.1 (C)
- net NANO_RST: now also SW1.2 (D)
Changed lines of the file:
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@@
     )
   )
+  (global_label "NANO_RST" (shape input) (at 313.69 210.82 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 326.17 210.82 0)
+      (effects (font (size 1.27 1.27)) (justify left) hide)
+    )
+  )
   (global_label "Row 3" (shape input) (at 27.94 133.35 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
@@
     )
   )
+  (symbol (lib_id "power:GND") (at 303.53 210.82 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR010" (at 303.53 217.17 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 303.53 215.9 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 303.53 210.82 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 303.53 210.82 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "k3yb.it"
+        (path "/fdcdebbe-06f2-4fc5-9da1-e0bd91f1985b"
+          (reference "#PWR010") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "ScottoKeebs:Placeholder_Keyswitch") (at 111.76 58.42 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
         )
       )
+    )
+  )
+  (symbol (lib_id "Switch:SW_Push_Dual_x2") (at 308.61 210.82 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "SW1" (at 308.61 203.2 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "Nice!Nano Reset" (at 308.61 205.74 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "Button_Switch_THT:SW_PUSH_1P1T_6x3.5mm_H4.3_APEM_MJTP1243" (at 308.61 205.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 308.61 205.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "3")
+    (pin "2")
+    (pin "4")
+    (pin "1")
+    (instances
+      (project "k3yb.it"
+        (path "/fdcdebbe-06f2-4fc5-9da1-e0bd91f1985b"
+          (reference "SW1") (unit 1)
+        )
+      )
