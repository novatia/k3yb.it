File: k3yb.it/k3yb.it.kicad_pcb (KiCad board)
At the start: 2 copper layers, 454.6 x 149.8 mm, 231 parts, among them U1 Nice_Nano_V2, U2 4052, U5 CD74HC4067M

Commit message: added correct footprint soic16
Parts:
- U2: footprint Package_SO:TSSOP-16-1EP_4.4x5mm_P0.65mm_EP3x3mm -> Package_SO:SOP-16_4.55x10.3mm_P1.27mm
Changed lines of the file:
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@@
       (sketchpadsonfab false)
       (subtractmaskfromsilk false)
-      (outputformat 1)
+      (outputformat 4)
       (mirror false)
       (drillshape 0)
@@
     )
   )
-  (footprint "Package_SO:TSSOP-16-1EP_4.4x5mm_P0.65mm_EP3x3mm" (layer "B.Cu")
+  (footprint "Package_SO:SOP-16_4.55x10.3mm_P1.27mm" (layer "B.Cu")
     (at 428.92 36.022 -90)
-    (descr "TSSOP, 16 Pin (Allegro A4954 https://www.allegromicro.com/-/media/Files/Datasheets/A4954-Datasheet.ashx), generated with kicad-footprint-generator ipc_gullwing_generator.py")
-    (tags "TSSOP SO")
+    (descr "SOP, 16 Pin (https://toshiba.semicon-storage.com/info/docget.jsp?did=12855&prodName=TLP290-4), generated with kicad-footprint-generator ipc_gullwing_generator.py")
+    (tags "SOP SO")
     (property "Sheetfile" "k3yb.it.kicad_sch")
     (property "Sheetname" "")
@@
     (property "ki_keywords" "CMOS MUX MUX4")
     (attr smd)
-    (fp_text reference "U2" (at 0 3.45 90) (layer "B.SilkS")
+    (fp_text reference "U2" (at 0 6.1 90) (layer "B.SilkS")
         (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
     )
-    (fp_text value "4052" (at 0 -3.45 90) (layer "B.Fab")
+    (fp_text value "4052" (at 0 -6.1 90) (layer "B.Fab")
         (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
     )
@@
         (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
     )
-    (fp_line (start 0 -2.735) (end -2.2 -2.735)
+    (fp_line (start -2.385 -5.26) (end -2.385 -5.005)
       (stroke (width 0.12) (type solid)) (layer "B.SilkS"))
-    (fp_line (start 0 -2.735) (end 2.2 -2.735)
+    (fp_line (start -2.385 5.005) (end -4.05 5.005)
       (stroke (width 0.12) (type solid)) (layer "B.SilkS"))
-    (fp_line (start 0 2.735) (end -3.65 2.735)
+    (fp_line (start -2.385 5.26) (end -2.385 5.005)
       (stroke (width 0.12) (type solid)) (layer "B.SilkS"))
-    (fp_line (start 0 2.735) (end 2.2 2.735)
+    (fp_line (start 0 -5.26) (end -2.385 -5.26)
       (stroke (width 0.12) (type solid)) (layer "B.SilkS"))
-    (fp_line (start -3.9 -2.75) (end 3.9 -2.75)
+    (fp_line (start 0 -5.26) (end 2.385 -5.26)
+      (stroke (width 0.12) (type solid)) (layer "B.SilkS"))
+    (fp_line (start 0 5.26) (end -2.385 5.26)
+      (stroke (width 0.12) (type solid)) (layer "B.SilkS"))
+    (fp_line (start 0 5.26) (end 2.385 5.26)
+      (stroke (width 0.12) (type solid)) (layer "B.SilkS"))
+    (fp_line (start 2.385 -5.26) (end 2.385 -5.005)
+      (stroke (width 0.12) (type solid)) (layer "B.SilkS"))
+    (fp_line (start 2.385 5.26) (end 2.385 5.005)
+      (stroke (width 0.12) (type solid)) (layer "B.SilkS"))
+    (fp_line (start -4.3 -5.4) (end 4.3 -5.4)
       (stroke (width 0.05) (type solid)) (layer "B.CrtYd"))
-    (fp_line (start -3.9 2.75) (end -3.9 -2.75)
+    (fp_line (start -4.3 5.4) (end -4.3 -5.4)
       (stroke (width 0.05) (type solid)) (layer "B.CrtYd"))
-    (fp_line (start 3.9 -2.75) (end 3.9 2.75)
+    (fp_line (start 4.3 -5.4) (end 4.3 5.4)
       (stroke (width 0.05) (type solid)) (layer "B.CrtYd"))
-    (fp_line (start 3.9 2.75) (end -3.9 2.75)
+    (fp_line (start 4.3 5.4) (end -4.3 5.4)
       (stroke (width 0.05) (type solid)) (layer "B.CrtYd"))
-    (fp_line (start -2.2 -2.5) (end -2.2 1.5)
+    (fp_line (start -2.275 -5.15) (end -2.275 4.15)
       (stroke (width 0.1) (type solid)) (layer "B.Fab"))
-    (fp_line (start -2.2 1.5) (end -1.2 2.5)
+    (fp_line (start -2.275 4.15) (end -1.275 5.15)
       (stroke (width 0.1) (type solid)) (layer "B.Fab"))
-    (fp_line (start -1.2 2.5) (end 2.2 2.5)
+    (fp_line (start -1.275 5.15) (end 2.275 5.15)
       (stroke (width 0.1) (type solid)) (layer "B.Fab"))
-    (fp_line (start 2.2 -2.5) (end -2.2 -2.5)
+    (fp_line (start 2.275 -5.15) (end -2.275 -5.15)
       (stroke (width 0.1) (type solid)) (layer "B.Fab"))
-    (fp_line (start 2.2 2.5) (end 2.2 -2.5)
+    (fp_line (start 2.275 5.15) (end 2.275 -5.15)
       (stroke (width 0.1) (type solid)) (layer "B.Fab"))
-    (pad "" smd roundrect (at -0.75 -0.75 270) (size 1.21 1.21) (layers "B.Paste") (roundrect_rratio 0.206612))
-    (pad "" smd roundrect (at -0.75 0.75 270) (size 1.21 1.21) (layers "B.Paste") (roundrect_rratio 0.206612))
-    (pad "" smd roundrect (at 0.75 -0.75 270) (size 1.21 1.21) (layers "B.Paste") (roundrect_rratio 0.206612))
-    (pad "" smd roundrect (at 0.75 0.75 270) (size 1.21 1.21) (layers "B.Paste") (roundrect_rratio 0.206612))
-    (pad "1" smd roundrect (at -2.875 2.275 270) (size 1.55 0.4) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
+    (pad "1" smd roundrect (at -3.25 4.445 270) (size 1.6 0.6) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
       (net 152 "BLOC NUM LED") (pinfunction "Y0") (pintype "passive"))
-    (pad "2" smd roundrect (at -2.875 1.625 270) (size 1.55 0.4) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
+    (pad "2" smd roundrect (at -3.25 3.175 270) (size 1.6 0.6) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
       (net 149 "unconnected-(U2-Y2-Pad2)") (pinfunction "Y2") (pintype "passive+no_connect"))
-    (pad "3" smd roundrect (at -2.875 0.975 270) (size 1.55 0.4) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
+    (pad "3" smd roundrect (at -3.25 1.905 270) (size 1.6 0.6) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
       (net 22 "HIGH") (pinfunction "Y") (pintype "passive"))
-    (pad "4" smd roundrect (at -2.875 0.325 270) (size 1.55 0.4) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
+    (pad "4" smd roundrect (at -3.25 0.635 270) (size 1.6 0.6) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
       (net 150 "unconnected-(U2-Y3-Pad4)") (pinfunction "Y3") (pintype "passive+no_connect"))
-    (pad "5" smd roundrect (at -2.875 -0.325 270) (size 1.55 0.4) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
+    (pad "5" smd roundrect (at -3.25 -0.635 270) (size 1.6 0.6) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
       (net 151 "unconnected-(U2-Y1-Pad5)") (pinfunction "Y1") (pintype "passive+no_connect"))
-    (pad "6" smd roundrect (at -2.875 -0.975 270) (size 1.55 0.4) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
+    (pad "6" smd roundrect (at -3.25 -1.905 270) (size 1.6 0.6) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
       (net 1 "LOW") (pinfunction "Inh") (pintype "input"))
-    (pad "7" smd roundrect (at -2.875 -1.625 270) (size 1.55 0.4) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
+    (pad "7" smd roundrect (at -3.25 -3.175 270) (size 1.6 0.6) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
       (net 1 "LOW") (pinfunction "VEE") (pintype "power_in"))
-    (pad "8" smd roundrect (at -2.875 -2.275 270) (size 1.55 0.4) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
+    (pad "8" smd roundrect (at -3.25 -4.445 270) (size 1.6 0.6) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
       (net 1 "LOW") (pinfunction "VSS") (pintype "power_in"))
-    (pad "9" smd roundrect (at 2.875 -2.275 270) (size 1.55 0.4) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
+    (pad "9" smd roundrect (at 3.25 -4.445 270) (size 1.6 0.6) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
       (net 148 "LED_MUX 2") (pinfunction "B") (pintype "input"))
-    (pad "10" smd roundrect (at 2.875 -1.625 270) (size 1.55 0.4) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
+    (pad "10" smd roundrect (at 3.25 -3.175 270) (size 1.6 0.6) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
       (net 147 "LED_MUX 1") (pinfunction "A") (pintype "input"))
-    (pad "11" smd roundrect (at 2.875 -0.975 270) (size 1.55 0.4) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
+    (pad "11" smd roundrect (at 3.25 -1.905 270) (size 1.6 0.6) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
       (net 153 "BLOC SCORR LED") (pinfunction "X3") (pintype "passive"))
-    (pad "12" smd roundrect (at 2.875 -0.325 270) (size 1.55 0.4) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
+    (pad "12" smd roundrect (at 3.25 -0.635 270) (size 1.6 0.6) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
       (net 156 "AUDIO ON LED") (pinfunction "X0") (pintype "passive"))
-    (pad "13" smd roundrect (at 2.875 0.325 270) (size 1.55 0.4) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
+    (pad "13" smd roundrect (at 3.25 0.635 270) (size 1.6 0.6) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
       (net 22 "HIGH") (pinfunction "X") (pintype "passive"))
-    (pad "14" smd roundrect (at 2.875 0.975 270) (size 1.55 0.4) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
+    (pad "14" smd roundrect (at 3.25 1.905 270) (size 1.6 0.6) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
       (net 155 "MIC ON LED") (pinfunction "X1") (pintype "passive"))
-    (pad "15" smd roundrect (at 2.875 1.625 270) (size 1.55 0.4) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
+    (pad "15" smd roundrect (at 3.25 3.175 270) (size 1.6 0.6) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
       (net 154 "CAPS LOCK LED") (pinfunction "X2") (pintype "passive"))
-    (pad "16" smd roundrect (at 2.875 2.275 270) (size 1.55 0.4) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
+    (pad "16" smd roundrect (at 3.25 4.445 270) (size 1.6 0.6) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.25)
       (net 22 "HIGH") (pinfunction "VDD") (pintype "power_in"))
-    (pad "17" smd rect (at 0 0 270) (size 3 3) (layers "B.Cu" "B.Mask"))
-    (model "${KICAD6_3DMODEL_DIR}/Package_SO.3dshapes/TSSOP-16-1EP_4.4x5mm_P0.65mm_EP3x3mm.wrl"
+    (model "${KICAD6_3DMODEL_DIR}/Package_SO.3dshapes/SOP-16_4.55x10.3mm_P1.27mm.wrl"
       (offset (xyz 0 0 0))
       (scale (xyz 1 1 1))

Commit message: sbroglio led
Parts:
- removed D96: AUDIO ON, LED_THT:LED_D3.0mm
- removed R5: 180, Resistor_THT:R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
- moved R2 10.2 mm to (445.5, 44.7)
- moved R3 9.22 mm to (445.5, 52.7)
- moved R4 2.91 mm to (445.5, 48.7)
- moved R1 2.65 mm to (445.5, 40.7)
- moved U2 0.53 mm to (429.2, 35.6), turned to 180 degrees
- moved D32 0.51 mm to (449.7, 31.4)
- moved D79 0.51 mm to (437.5, 31.4)
- moved D80 0.51 mm to (443.6, 31.4)
- moved D95 0.51 mm to (455.8, 31.4)
Connections:
- U1 pad 12: unconnected-(U1-D9-Pad12) -> LED_OUTPUT
- U2 pad 11: BLOC SCORR LED -> LED_OUTPUT
- U2 pad 12: AUDIO ON LED -> LED_OUTPUT
- U2 pad 14: MIC ON LED -> LED_OUTPUT
- U2 pad 15: CAPS LOCK LED -> LED_OUTPUT
- U2 pad 2: unconnected-(U2-Y2-Pad2) -> BLOC SCORR LED
- U2 pad 4: unconnected-(U2-Y3-Pad4) -> MIC ON LED
- U2 pad 5: unconnected-(U2-Y1-Pad5) -> CAPS LOCK LED
Routing:
- net LOW: track 73.1 -> 122.8 mm, vias 0 -> 2
- net LED_MUX 1: track 0.74 -> 48.5 mm, vias 0 -> 2
- net LED_MUX 2: track 0.00 -> 37.3 mm, vias 0 -> 1
- net LED_OUTPUT: track 0.00 -> 34.8 mm, vias 0 -> 1
- net Net-(D79-A): track 0.00 -> 23.2 mm
- net CAPS LOCK LED: track 0.00 -> 20.0 mm
- net Net-(D95-A): track 0.00 -> 19.0 mm
- net MIC ON LED: track 0.00 -> 16.9 mm
- net HIGH: track 33.6 -> 49.5 mm
- net BLOC SCORR LED: track 0.00 -> 15.0 mm
- net Net-(D32-A): track 0.00 -> 12.5 mm
- net BLOC NUM LED: track 0.00 -> 11.9 mm
- net Net-(D80-A): track 0.00 -> 7.52 mm
- net NANO_MUX 3: track 51.8 -> 52.4 mm
