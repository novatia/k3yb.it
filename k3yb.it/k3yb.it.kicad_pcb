# Repository novatia/k3yb.it

## KiCad design k3yb.it/k3yb.it.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D97, D98, D99, D100, D101, D102, D103, D104, D105, D106, D107, D108, D109, D110: Diode; Diode_SOD-123
D32: BLOC SCORR; LED_D3.0mm
D79: CAPS LOCK; LED_D3.0mm
D80: BLOC NUM; LED_D3.0mm
D95: MIC ON; LED_D3.0mm
J1: Display i2c; JST_PH_B4B-PH-SM4-TB_1x04-1MP_P2.00mm_Vertical
J2: Nice Nano i2c; PinHeader_1x03_P2.54mm_Vertical_SMD_Pin1Left
J3: 18650 battery socket; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal
R1, R2, R3, R4: 180; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
S1: Esc; Hotswap_MX_Plated
S2: F1; Hotswap_MX_Plated
S3: F2; Hotswap_MX_Plated
S4: F3; Hotswap_MX_Plated
S5: F4; Hotswap_MX_Plated
S6: F5; Hotswap_MX_Plated
S7: F6; Hotswap_MX_Plated
S8: F7; Hotswap_MX_Plated
S9: F8; Hotswap_MX_Plated
S10: F9; Hotswap_MX_Plated
S11: F10; Hotswap_MX_Plated
S12: F11; Hotswap_MX_Plated
S13: F12; Hotswap_MX_Plated
S14: Stamp; Hotswap_MX_Plated
S15: Bloc scorr; Hotswap_MX_Plated
S16: Pause; Hotswap_MX_Plated
S17: tilde; Hotswap_MX_Plated
S18, S108: 1; Hotswap_MX_Plated
S19, S109: 2; Hotswap_MX_Plated
S20, S110: 3; Hotswap_MX_Plated
S21, S105: 4; Hotswap_MX_Plated
S22, S106: 5; Hotswap_MX_Plated
S23, S107: 6; Hotswap_MX_Plated
S24, S101: 7; Hotswap_MX_Plated
S25, S102: 8; Hotswap_MX_Plated
S26, S103: 9; Hotswap_MX_Plated
S27, S92: 0; Hotswap_MX_Plated
S28, S100: -; Hotswap_MX_Plated
S29: =; Hotswap_MX_Plated
S30: Backspace; Hotswap_MX_Plated
S31: ù; Hotswap_MX_Plated
S33: Tab; Hotswap_MX_Plated
S34: q; Hotswap_MX_Plated
S35: w; Hotswap_MX_Plated
S36: e; Hotswap_MX_Plated
S37: r; Hotswap_MX_Plated
S38: t; Hotswap_MX_Plated
S39: y; Hotswap_MX_Plated
S40: u; Hotswap_MX_Plated
S41: i; Hotswap_MX_Plated
S42: o; Hotswap_MX_Plated
S43: p; Hotswap_MX_Plated
S44: {; Hotswap_MX_Plated
S45: }; Hotswap_MX_Plated
S46: ins; Hotswap_MX_Plated
S47, S78: up; Hotswap_MX_Plated
S48: pg up; Hotswap_MX_Plated
S49: Caps lock; Hotswap_MX_Plated
S50: a; Hotswap_MX_Plated
S51: s; Hotswap_MX_Plated
S52: d; Hotswap_MX_Plated
S53: f; Hotswap_MX_Plated
S54: g; Hotswap_MX_Plated
S55: h; Hotswap_MX_Plated
S56: j; Hotswap_MX_Plated
S57: k; Hotswap_MX_Plated
S58: l; Hotswap_MX_Plated
S59: ;; Hotswap_MX_Plated
S60: '; Hotswap_MX_Plated
S61, S94: enter; Hotswap_MX_Plated
S62: del; Hotswap_MX_Plated
S63: end; Hotswap_MX_Plated
S64: pg dowm; Hotswap_MX_Plated
S65: Left Shift; Hotswap_MX_Plated
S66: \; Hotswap_MX_Plated
S67: z; Hotswap_MX_Plated
S68: x; Hotswap_MX_Plated
S69: c; Hotswap_MX_Plated
S70: v; Hotswap_MX_Plated
S71: b; Hotswap_MX_Plated
S72: n; Hotswap_MX_Plated
S73: m; Hotswap_MX_Plated
S74: ,; Hotswap_MX_Plated
S75, S93: .; Hotswap_MX_Plated
S76, S98: /; Hotswap_MX_Plated
S77: right shift; Hotswap_MX_Plated
S81: left ctrl; Hotswap_MX_Plated
S82: win; Hotswap_MX_Plated
S83: left alt; Hotswap_MX_Plated
S84: space; Hotswap_MX_Plated
S85: right alt; Hotswap_MX_Plated
S86: fn; Hotswap_MX_Plated
S87: menu; Hotswap_MX_Plated
S88: right ctrl; Hotswap_MX_Plated
S89: left; Hotswap_MX_Plated
S90: down; Hotswap_MX_Plated
S91: right; Hotswap_MX_Plated
S97: num; Hotswap_MX_Plated
S99: *; Hotswap_MX_Plated
S104: +; Hotswap_MX_Plated
SW1: Nice!Nano Reset; SW_PUSH_1P1T_6x3.5mm_H4.3_APEM_MJTP1243
U1: Nice_Nano_V2
U2: 4052; SOP-16_4.55x10.3mm_P1.27mm
U5: CD74HC4067M; SOIC-24W_7.5x15.4mm_P1.27mm

Connections:
B+: J3.1, U1.24 (B+)
BLOC NUM LED: R1.2, U2.1 (Y0)
BLOC SCORR LED: R2.2, U2.2 (Y2)
CAPS LOCK LED: R3.2, U2.5 (Y1)
Col 0: S1.1, S17.1, S33.1, S49.1, S65.1, S81.1, U5.23 (I8)
Col 1: S2.1, S18.1, S34.1, S50.1, S66.1, S82.1, U5.22 (I9)
Col 2: S3.1, S19.1, S35.1, S51.1, S67.1, S83.1, U5.21 (I10)
Col 3: S4.1, S20.1, S36.1, S52.1, S68.1, S84.1, U5.20 (I11)
Col 4: S5.1, S21.1, S37.1, S53.1, S69.1, U5.19 (I12)
Col 5: S6.1, S22.1, S38.1, S54.1, S70.1, U5.18 (I13)
Col 6: S7.1, S23.1, S39.1, S55.1, S71.1, U5.17 (I14)
Col 7: S8.1, S24.1, S40.1, S56.1, S72.1, U5.16 (I15)
Col 8: S9.1, S25.1, S41.1, S57.1, S73.1, S85.1, U5.2 (I7)
Col 9: S10.1, S26.1, S42.1, S58.1, S74.1, S86.1, U5.3 (I6)
Col 10: S11.1, S27.1, S43.1, S59.1, S75.1, S87.1, S91.1, U5.4 (I5)
Col 11: S12.1, S28.1, S44.1, S60.1, S76.1, S88.1, U5.5 (I4)
Col 12: S13.1, S29.1, S31.1, S45.1, S61.1, S77.1, U5.6 (I3)
Col 13: S14.1, S30.1, S46.1, S62.1, S89.1, U5.7 (I2)
Col 14: S15.1, S47.1, S63.1, S90.1, U5.8 (I1)
Col 15: S16.1, S48.1, S64.1, S78.1, U5.9 (I0)
HIGH: J1.2, U1.21 (3.3v), U2.11 (X3), U2.12 (X0), U2.14 (X1), U2.15 (X2), U2.16 (VDD), U5.1 (COM), U5.24 (VCC)
LAYER ON LED: R4.2, U2.4 (Y3)
LED_MUX 1: U1.1 (D1), U2.10 (A)
LED_MUX 2: U1.2 (D0), U2.9 (B)
LED_OUTPUT: U1.12 (D9), U2.6 (Inh)
LOW: D32.1 (K), D79.1 (K), D80.1 (K), D95.1 (K), J1.1, J3.2, SW1.1 (C), U1.3 (GND), U1.4 (GND), U1.23 (GND), U2.7 (VEE), U2.8 (VSS), U5.12 (GND), U5.15 (~E)
NANO_MUX 1: U1.20 (D21), U5.10 (S0)
NANO_MUX 2: U1.19 (D20), U5.11 (S1)
NANO_MUX 3: U1.18 (D19), U5.14 (S2)
NANO_MUX 4: U1.17 (D18), U5.13 (S3)
NANO_RST: SW1.2 (D), U1.22 (RST)
unnamed: D1.2 (A), S1.2
unnamed: D2.2 (A), S2.2
unnamed: D3.2 (A), S3.2
unnamed: D4.2 (A), S4.2
unnamed: D5.2 (A), S5.2
unnamed: D6.2 (A), S6.2
unnamed: D7.2 (A), S7.2
unnamed: D8.2 (A), S8.2
unnamed: D9.2 (A), S9.2
unnamed: D10.2 (A), S10.2
unnamed: D11.2 (A), S11.2
unnamed: D12.2 (A), S12.2
unnamed: D13.2 (A), S13.2
unnamed: D14.2 (A), S14.2
unnamed: D15.2 (A), S15.2
unnamed: D16.2 (A), S16.2
unnamed: D17.2 (A), S17.2
unnamed: D18.2 (A), S18.2
unnamed: D19.2 (A), S19.2
unnamed: D20.2 (A), S20.2
unnamed: D21.2 (A), S21.2
unnamed: D22.2 (A), S22.2
unnamed: D23.2 (A), S23.2
unnamed: D24.2 (A), S24.2
unnamed: D25.2 (A), S25.2
unnamed: D26.2 (A), S26.2
unnamed: D27.2 (A), S27.2
unnamed: D28.2 (A), S28.2
unnamed: D29.2 (A), S29.2
unnamed: D30.2 (A), S30.2
unnamed: D31.2 (A), S31.2
unnamed: D32.2 (A), R2.1
unnamed: D33.2 (A), S33.2
unnamed: D34.2 (A), S34.2
unnamed: D35.2 (A), S35.2
unnamed: D36.2 (A), S36.2
unnamed: D37.2 (A), S37.2
unnamed: D38.2 (A), S38.2
unnamed: D39.2 (A), S39.2
unnamed: D40.2 (A), S40.2
unnamed: D41.2 (A), S41.2
unnamed: D42.2 (A), S42.2
unnamed: D43.2 (A), S43.2
unnamed: D44.2 (A), S44.2
unnamed: D45.2 (A), S45.2
unnamed: D46.2 (A), S46.2
unnamed: D47.2 (A), S47.2
unnamed: D48.2 (A), S48.2
unnamed: D49.2 (A), S49.2
unnamed: D50.2 (A), S50.2
unnamed: D51.2 (A), S51.2
unnamed: D52.2 (A), S52.2
unnamed: D53.2 (A), S53.2
unnamed: D54.2 (A), S54.2
unnamed: D55.2 (A), S55.2
unnamed: D56.2 (A), S56.2
unnamed: D57.2 (A), S57.2
unnamed: D58.2 (A), S58.2
unnamed: D59.2 (A), S59.2
unnamed: D60.2 (A), S60.2
unnamed: D61.2 (A), S61.2
unnamed: D62.2 (A), S62.2
unnamed: D63.2 (A), S63.2
unnamed: D64.2 (A), S64.2
unnamed: D65.2 (A), S65.2
unnamed: D66.2 (A), S66.2
unnamed: D67.2 (A), S67.2
unnamed: D68.2 (A), S68.2
unnamed: D69.2 (A), S69.2
unnamed: D70.2 (A), S70.2
unnamed: D71.2 (A), S71.2
unnamed: D72.2 (A), S72.2
unnamed: D73.2 (A), S73.2
unnamed: D74.2 (A), S74.2
unnamed: D75.2 (A), S75.2
unnamed: D76.2 (A), S76.2
unnamed: D77.2 (A), S77.2
unnamed: D78.2 (A), S78.2
unnamed: D79.2 (A), R3.1
unnamed: D80.2 (A), R1.1
unnamed: D81.2 (A), S81.2
unnamed: D82.2 (A), S82.2
unnamed: D83.2 (A), S83.2
unnamed: D84.2 (A), S84.2
unnamed: D85.2 (A), S85.2
unnamed: D86.2 (A), S86.2
unnamed: D87.2 (A), S87.2
unnamed: D88.2 (A), S88.2
unnamed: D89.2 (A), S89.2
unnamed: D90.2 (A), S90.2
unnamed: D91.2 (A), S91.2
unnamed: D92.2 (A), S92.2
unnamed: D93.2 (A), S93.2
unnamed: D94.2 (A), S94.2
unnamed: D95.2 (A), R4.1
unnamed: D97.2 (A), S97.2
unnamed: D98.2 (A), S98.2
unnamed: D99.2 (A), S99.2
unnamed: D100.2 (A), S100.2
unnamed: D101.2 (A), S101.2
unnamed: D102.2 (A), S102.2
unnamed: D103.2 (A), S103.2
unnamed: D104.2 (A), S104.2
unnamed: D105.2 (A), S105.2
unnamed: D106.2 (A), S106.2
unnamed: D107.2 (A), S107.2
unnamed: D108.2 (A), S108.2
unnamed: D109.2 (A), S109.2
unnamed: D110.2 (A), S110.2
unnamed: U2.3 (Y), U2.13 (X)
Pad Col 0: S92.1, S97.1, S101.1, S105.1, S108.1, U1.13 (D10)
Pad Col 1: S98.1, S102.1, S106.1, S109.1, U1.14 (D16)
Pad Col 2: S93.1, S99.1, S103.1, S107.1, S110.1, U1.15 (D14)
Pad Col 3: S94.1, S100.1, S104.1, U1.16 (D15)
Row 0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D97.1 (K), D98.1 (K), D99.1 (K), D100.1 (K), U1.11 (D8)
Row 1: D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D101.1 (K), D102.1 (K), D103.1 (K), D104.1 (K), U1.10 (D7)
Row 2: D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D105.1 (K), D106.1 (K), D107.1 (K), U1.9 (D6)
Row 3: D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D108.1 (K), D109.1 (K), D110.1 (K), U1.8 (D5)
Row 4: D65.1 (K), D66.1 (K), D67.1 (K), D68.1 (K), D69.1 (K), D70.1 (K), D71.1 (K), D72.1 (K), D73.1 (K), D74.1 (K), D75.1 (K), D76.1 (K), D77.1 (K), D78.1 (K), D92.1 (K), D93.1 (K), D94.1 (K), U1.7 (D4)
Row 5: D31.1 (K), D81.1 (K), D82.1 (K), D83.1 (K), D84.1 (K), D91.1 (K), U1.6 (D3)
Row 6: D85.1 (K), D86.1 (K), D87.1 (K), D88.1 (K), D89.1 (K), D90.1 (K), U1.5 (D2)
SCL: J1.3, J2.2
SDA: J1.4, J2.1

Notes on the sheet:
COLUMN MULTIPLEXING
MATRIX 112

Board: 2 copper layers, 454.6 x 149.8 mm, 233 parts (109 on the bottom side), 154 nets.

Other parts of the board:
M3, M3#2, M3#3, M3#4, M3#5, M3#6, M3#7, M3#8: MountingHole_3.2mm_M3

## Commit log (part)

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2024-01-29 first import
2024-01-31 alligned component Soldering MX version
2024-01-31 minors
2024-02-06 update schema
2024-02-09 pcb and schematic v1.0b
2024-02-21 added correct footprint soic16
2024-03-19 fixed LED schematics
2024-03-27 sbroglio led
2024-04-02 added Gerber fixed led output multiplexing
2024-04-02 added user drawings
2024-04-02 renamed M3 screws reference
2024-05-01 added stabilizer mounting holes
2024-05-07 added dxf, added reset switch
2024-05-07 added pro-micro pinout on silkscreen
2024-05-07 moved docs
